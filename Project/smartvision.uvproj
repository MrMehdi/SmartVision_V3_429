# Keil uVision project smartvision.uvproj, settings and files
target SmartVision (ARM-ADS)
  device: STM32F429VI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: smv3 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USER_MSG_ENB,WRITEIMAGEHEADER,M16,DBG_FLASH
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ../Libraries/: startup_stm32f4xx.s
    ../src/: system_stm32f4xx.c
  group Driver/Hal
    ../src/: stm32f4xx_it.c
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c
  group App
    ../src/: main.c serialcom.c camapi.c SCCB.C flash.c camdrv.c
